Commit message: 210816

File: mm_hyu_coarse/right_sim.urdf (robot description, URDF)
Before this commit: robot hyuspa, 20 links, 19 joints
Joints:
- joint lin_x_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0.075 rpy=0 0 0
